SRC_URI:append = " file://0001-Add-prophesee-media-formats.patch"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
